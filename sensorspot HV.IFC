Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: sensorspot 2021.IFC
Time: 2021-03-15T14:21:04
Written by: SwIFC
Made in: SolidWorks 2020

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: sensorspot 2021
In: Default Storey
PredefinedType: ELEMENT; Material: Steel
